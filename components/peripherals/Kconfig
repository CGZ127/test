## components/peripherals/Kconfig
```kconfig
menu "PERPHERALS"
config PERIPHERALS_ENABLE
bool "Enable PERIPHERALS"
default "y"
endmenu
```
